# Keil uVision project gl-starterkit-v2.uvprojx, settings and files
target hw_test_glskv2 (6190000::V6.19::ARMCLANG)
  device: STM32H562ZGTx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00100000) IROM2(0x0C000000,0x00100000) XRAM(0x20040000,0x00010000) XRAM2(0x30040000,0x00010000) XRAM3(0x20050000,0x00050000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: ..\bin\GLSKv2_testFW_v1_0 +hex
  AfterMake: arm-none-eabi-size obj\fw.elf
  group src/platform
    ./src/platform/stm32h562xx/: startup.c irq.c clock.c gpio.c systick.c i2c.c spi.c adc.c pwm_tim.c console.c
    ./src/platform/: eeprom.c hd44780.c gpio_keypad.c htu21d.c apds9250.c pwm_pca9685.c led_ws2812.c lsm6dso.c lis2mdl.c flash_nor.c
  group src
    ./src/: main.c board.c tests.c
